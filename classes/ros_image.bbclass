# Metadata common to all ROS images.
#
# Copyright (c) 2019 LG Electronics, Inc.
