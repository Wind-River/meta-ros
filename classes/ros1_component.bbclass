# Copyright (c) 2019 LG Electronics, Inc.

inherit ros_component

# Place metadata unique to components of type "ros1" here.
